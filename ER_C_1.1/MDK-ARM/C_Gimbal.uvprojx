# Keil uVision project C_Gimbal.uvprojx, settings and files
target C_Gimbal (6180000::V6.18::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: C_Gimbal +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/Include;../Drivers/CMSIS/DSP/Include/dsp;../Drivers/CMSIS/Lib/ARM;../CustomCode/Apps/Apps.h;../CustomCode/Algorithm/Algorithm.h;../CustomCode/BSP/BSP.h;../CustomCode/Devices/Devices.h;../CustomCode/Devices;../CustomCode/Tasks/Tasks.h;../CustomCode/Unify;../CustomCode/Unify/Universe.h;../CustomCode/Algorithm/Algorithm.cpp;../CustomCode/Algorithm;../CustomCode/Tasks;../CustomCode/Devices/BMI088
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c can.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Algorithm
    ../CustomCode/Algorithm/Algorithm.cpp/: ALGO_Filter.cpp ALGO_PID.cpp ALGO_Ramp.cpp ALGO_Kalman.cpp
    ../CustomCode/Algorithm/: ALGO_Math.h
  group Apps
    ../CustomCode/Apps/Apps.cpp/: APP_Vision.cpp APP_Devices.cpp APP_DR16.cpp APP_Gimbal.cpp APP_Shoot.cpp APP_Clamp.cpp
  group BSP
    ../CustomCode/BSP/BSP.c/: BSP_CAN.c BSP_FLASH.c BSP_FlashStore.c BSP_PVD.c BSP_UART.c BSP_SPI.c BSP_ADC.c
  group Devices
    ../CustomCode/Devices/Devices.cpp/: DEV_Buzzer.cpp DEV_CIMU.cpp DEV_COMM.cpp DEV_DR16.cpp DEV_Timer.cpp DEV_UpComputer.cpp DEV_LED.cpp DEV_BrtEncoder.cpp DEV_BsqJnP2.cpp DEV_MX106.cpp
    ../CustomCode/Devices/: DEV_Motor.h
  group Tasks
    ../CustomCode/Tasks/Tasks.cpp/: TASK_Can.cpp TASK_Check.cpp TASK_Control.cpp TASK_Waveform.cpp TASK_LED.cpp
  group Universe
    ../CustomCode/Tasks/: Task_ALL.h
    ../CustomCode/Unify/Universe.cpp/: System_Config.cpp System_DataPool.cpp
  group Unify
    ../CustomCode/Unify/: confing.h include.h Wolf_Infantry.h
  group BMI088
    ../CustomCode/Devices/BMI088/: BMI088driver.c BMI088Middleware.c calibrate_task.c delay.c INS_task.c ist8310driver.c ist8310driver_middleware.c MahonyAHRS.c
software components: CMSIS:CORE 5.5.0
