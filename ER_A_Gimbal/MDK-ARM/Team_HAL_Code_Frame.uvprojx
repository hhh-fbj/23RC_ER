# Keil uVision project Team_HAL_Code_Frame.uvprojx, settings and files
target Team_HAL_Code_Frame (6190000::V6.19::ARMCLANG)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Team_HAL_Code_Frame +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: USE_HAL_DRIVER,STM32F427xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/Include;../Drivers/CMSIS/DSP/Include/dsp;../Drivers/CMSIS/Lib/ARM;../CustomCode/Apps/Apps.h;../CustomCode/Algorithm/Algorithm.h;../CustomCode/BSP/BSP.h;../CustomCode/Devices/Devices.h;../CustomCode/Devices;../CustomCode/Tasks/Tasks.h;../CustomCode/Unify;../CustomCode/Unify/Universe.h;../CustomCode/Algorithm;../CustomCode/Tasks
  asm include: ..\Inc;../Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User
    ../Src/: main.c gpio.c freertos.c adc.c can.c dma.c iwdg.c rng.c rtc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Algorithm
    ../CustomCode/Algorithm/Algorithm.cpp/: ALGO_Filter.cpp ALGO_Kalman.cpp ALGO_PID.cpp ALGO_Ramp.cpp
    ../CustomCode/Algorithm/: ALGO_Math.h
  group Apps
    ../CustomCode/Apps/Apps.cpp/: APP_Clamp.cpp APP_Devices.cpp APP_DR16.cpp APP_Gimbal.cpp APP_Shoot.cpp APP_Vision.cpp
  group BSP
    ../CustomCode/BSP/BSP.c/: BSP_CAN.c BSP_FLASH.c BSP_FlashStore.c BSP_PVD.c BSP_UART.c
  group Devices
    ../CustomCode/Devices/Devices.cpp/: DEV_COMM.cpp DEV_DR16.cpp DEV_AIMU.cpp DEV_UpComputer.cpp DEV_Buzzer.cpp DEV_Timer.cpp DEV_CIMU.cpp DEV_OLED.cpp DEV_SD.cpp DEV_RTC.cpp DEV_BrtEncoder.cpp DEV_Bldc.cpp DEV_Posture.cpp DEV_MX106.cpp DEV_Analog.cpp DEV_DT35.cpp DEV_DRF1609H.cpp
    ../CustomCode/Devices/: DEV_Motor.h
  group Tasks
    ../CustomCode/Tasks/Tasks.cpp/: TASK_Can.cpp TASK_Check.cpp TASK_Control.cpp TASK_Imu.cpp TASK_Waveform.cpp TASK_Vision.cpp
    ../CustomCode/Tasks/: Task_ALL.h
  group Universe
    ../CustomCode/Unify/Universe.cpp/: System_Config.cpp System_DataPool.cpp
  group Unify
    ../CustomCode/Unify/: include.h confing.h Wolf_Infantry.h
software components: CMSIS:CORE 5.5.0
